# Keil uVision project xadow_pebble_11u35.uvproj, settings and files
target mbed NXP LPC11U24 (ARM-ADS)
  device: LPC11U35/401 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: xadow_pebble_11u35
  AfterMake: $K\ARM\BIN\ELFDWT.EXE "!L"
  AfterMake: fromelf --bin -o xadow_pebble_11u35_LPC11U24.bin build\xadow_pebble_11u35.axf
  c flags: Optim=1
  c define: TARGET_LPC11U24,  TARGET_M0,  TARGET_CORTEX_M,  TARGET_NXP,  TARGET_LPC11UXX,  TARGET_LPC11U24_401,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M0,  ARM_MATH_CM0,  MBED_BUILD_TIMESTAMP=1438742237.82,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  USBDevice;  USBDevice/USBAudio;  USBDevice/USBDevice;  USBDevice/USBHID;  USBDevice/USBMIDI;  USBDevice/USBSerial;  USBDevice/USBMSD;  BufferedSerial;  BufferedSerial/Buffer;  XadowGPS;  mbed;  mbed/TARGET_LPC11U24;  mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO;  mbed/TARGET_LPC11U24/TARGET_NXP;  mbed/TARGET_LPC11U24/TARGET_NXP/TARGET_LPC11UXX;  mbed/TARGET_LPC11U24/TARGET_NXP/TARGET_LPC11UXX/TARGET_LPC11U24_401
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  scatter file: mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/LPC11U24.sct
  link misc: mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/sys.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/startup_LPC11xx.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/board.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/system_LPC11Uxx.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/cmsis_nvic.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/retarget.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/mbed.ar
  group src
    ./: hdlc.c PebbleSerial.c main.cpp
    USBDevice/USBAudio/: USBAudio.cpp
    USBDevice/USBDevice/: USBHAL_KL25Z.cpp USBHAL_STM32F4.cpp USBHAL_LPC17.cpp USBHAL_LPC11U.cpp USBHAL_LPC40.cpp USBHAL_RZ_A1H.cpp USBHAL_Maxim.cpp USBDevice.cpp
    USBDevice/USBHID/: USBMouse.cpp USBKeyboard.cpp USBMouseKeyboard.cpp USBHID.cpp
    USBDevice/USBMIDI/: USBMIDI.cpp
    USBDevice/USBSerial/: USBSerial.cpp USBCDC.cpp
    USBDevice/USBMSD/: USBMSD.cpp
    BufferedSerial/: BufferedSerial.cpp
    BufferedSerial/Buffer/: Buffer.cpp
    XadowGPS/: XadowGPS.cpp
  group h
    ./: PebbleSerial.h hdlc.h
    ./XadowGPS/: XadowGPS.h
